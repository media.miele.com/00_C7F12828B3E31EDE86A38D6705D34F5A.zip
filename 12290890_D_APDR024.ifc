Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-06-27T14:46:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 27 14:46:54 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\f5815aa8-8d3a-48a4-882a-4922486b773f\ff8a4e3f-5555-4845-a780-a391b0eca61d\ifc * Database version: 5507 * Database creation date: Tue Jun 27 14:46:49 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 27 14:46:49 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 27 14:46:49 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12290890_D_APDR024:59520024_D_12290890_APDR024, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 59520024_D_12290890_APDR024
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 59520024_D_12290890_APDR024
Pset_BuildingElementProxyCommon - sets with these values: 2
